Commit message: multirobotics env

File: gym-aeris/gym_aeris/data/base_4.urdf (robot description, URDF)
Before this commit: robot base, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=4 4 0.001; visual box size=4 4 0.01
