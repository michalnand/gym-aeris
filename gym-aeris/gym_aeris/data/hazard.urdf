Commit message: lidar added

File: gym-aeris/gym_aeris/data/hazard.urdf (robot description, URDF)
Before this commit: robot hazard, 1 links, 0 joints
Links:
- link baseLink: geometry collision cylinder length=0.01 radius=0.05; visual cylinder length=0.01 radius=0.15
