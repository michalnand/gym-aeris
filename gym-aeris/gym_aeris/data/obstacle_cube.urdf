Commit message: new envs

File: gym-aeris/gym_aeris/data/obstacle_cube.urdf (robot description, URDF)
Before this commit: robot fragile, 1 links, 0 joints
Links:
- link baseLink: geometry collision mesh filename=cube.obj scale=0.05 0.05 0.05; visual mesh filename=cube.obj scale=0.05 0.05 0.05
