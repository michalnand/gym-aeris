Commit message: lidar fixes

File: gym-aeris/gym_aeris/data/target.urdf (robot description, URDF)
Before this commit: robot target, 1 links, 0 joints
Links:
- link baseLink: geometry collision cylinder length=0.1 radius=0.05; visual cylinder length=0.1 radius=0.1
